# Keil uVision project WaterMeter.uvproj, settings and files
target WaterMeter (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WaterMeter +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Src/: main.c main.h
  group LCD1602
    ./Src/: LCD1602.c LCD1602.h
  group Flowmeter
    ./Src/: Flowmeter.c Flowmeter.h
  group Key
    ./Src/: Key.c Key.h
  group Timer
    ./Src/: Timer.c Timer.h
